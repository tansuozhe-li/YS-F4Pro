# IAR project YSF4Pro.ewp, settings and files
configuration YSF4Pro (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\Application\3-Device\DeviceCfg; ..\Application\3-Device\DeviceLte; ..\Application\3-Device\DeviceSystime; ..\Application\3-Device\DeviceTerm; ..\Application\4-Common; ..\Application\4-Common\Broadcast; ..\BSP\ec800k; ..\BSP\onchip_flash; ..\BSP\uartdev; ..\BSP\w25q256; ..\Drivers\Lib\Commlib; ..\Drivers\Lib\Getcfg; ..\Drivers\Lib\Ringbuff; ..\RT-Thread\bsp; ..\RT-Thread\components\finsh; ..\RT-Thread\include; ..\Drivers\Protocol\I1_gw2015; ..\Application\1-Business\DeepSensing; ..\Application\3-Device\DeviceIce; ..\Application\1-Business\NanWangGX
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DS_EITL_Hv1.0.0_APP_Sv1.0.600_20241201_01_YS.bin
  ILINK.IlinkOutputFile: YSF4Pro.out
  ILINK.IlinkIcfFile: stm32f407xx_flash_app.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/1-Business/CloudServices
    ../Application/1-Business/DeepSensing/: DeepSensing.c DeepSensing.h DeepSensing_main.c DeepSensingUpgrade.c DeepSensingUpgrade.h
  group Application/1-Business/NanWangGX
    ../Application/1-Business/NanWangGX/: NanWangGX.c NanWangGX.h NanWangGX_main.c
  group Application/3-Device/DeviceCfg
    ../Application/3-Device/DeviceCfg/: DeviceCfg.c DeviceCfg.h DeviceCfg_main.c
  group Application/3-Device/DeviceIce
    ../Application/3-Device/DeviceIce/: DeviceIce.c DeviceIce.h DeviceIce_main.c
  group Application/3-Device/DeviceLte
    ../Application/3-Device/DeviceLte/: DeviceLte.c DeviceLte.h DeviceLte_main.c
  group Application/3-Device/DeviceSystem
    ../Application/3-Device/DeviceSystime/: DeviceSystime.c DeviceSystime.h DeviceSystime_main.c
  group Application/3-Device/DeviceTerm
    ../Application/3-Device/DeviceTerm/: DeviceTerm.c DeviceTerm.h DeviceTermShell.c
  group Application/4-Common
    ../Application/4-Common/: common.c common.h thread_cfg.h
  group Application/4-Common/Broadcast
    ../Application/4-Common/Broadcast/: common_broadcast.c common_broadcast.h
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: gpio.c iwdg.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c usart.c
  group BSP/ec800k
    ../BSP/ec800k/: ec800k.c ec800k.h ec800k_atcmd.c ec800k_atcmd.h
  group BSP/onchip_flash
    ../BSP/onchip_flash/: onchip_flash.c onchip_flash.h
  group BSP/uartdev
    ../BSP/uartdev/: uart_dev.c uart_dev.h
  group BSP/w25q128
    ../BSP/w25q256/: w25q256.c w25q256.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/Lib/Commlib
    ../Drivers/Lib/Commlib/: assertions.h comm_types.h commlib.c commlib.h
  group Drivers/Lib/GetCfg
    ../Drivers/Lib/Getcfg/: getcfg.c getcfg.h
  group Drivers/Lib/Ringbuff
    ../Drivers/Lib/Ringbuff/: ring_buff.c ring_buff.h
  group Drivers/Protocol
    ../Drivers/Protocol/I1_gw2015/: I1Gw2015Protocol.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group RT-Thread/bsp
    ../RT-Thread/bsp/: board.c rtconfig.h
  group RT-Thread/components/finsh
    ../RT-Thread/components/finsh/: cmd.c finsh.h finsh_api.h msh.c msh.h shell.c shell.h
  group RT-Thread/includes
    ../RT-Thread/include/: broadcast.h rtdbg.h rtdebug.h rtdef.h rthw.h rtlibc.h rtm.h rtservice.h rtthread.h
  group RT-Thread/libcpu
    ../RT-Thread/libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group RT-Thread/src
    ../RT-Thread/src/: broadcast.c clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
